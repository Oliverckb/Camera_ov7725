<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Control</name>
    <group>
      <name>Identify</name>
      <file>
        <name>$PROJ_DIR$\Sources\Control\Identify\Identify.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Sources\Control\Identify\Identify.h</name>
      </file>
    </group>
    <group>
      <name>Motor</name>
      <file>
        <name>$PROJ_DIR$\Sources\Control\Motor\Motor.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Sources\Control\Motor\Motor.h</name>
      </file>
    </group>
    <group>
      <name>Servo</name>
      <file>
        <name>$PROJ_DIR$\Sources\Control\Servo\Servo.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Sources\Control\Servo\Servo.h</name>
      </file>
    </group>
    <group>
      <name>Speed</name>
      <file>
        <name>$PROJ_DIR$\Sources\Control\Speed\Speed.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Sources\Control\Speed\Speed.h</name>
      </file>
    </group>
  </group>
  <group>
    <name>Drivers</name>
    <group>
      <name>Delay</name>
      <file>
        <name>$PROJ_DIR$\Sources\Drivers\Delay\Delay.c</name>
      </file>
    </group>
    <group>
      <name>IO</name>
      <file>
        <name>$PROJ_DIR$\Sources\Drivers\IO\IO.c</name>
      </file>
    </group>
    <group>
      <name>PLL</name>
      <file>
        <name>$PROJ_DIR$\Sources\Drivers\PLL\PLL.c</name>
      </file>
    </group>
    <group>
      <name>PWM</name>
      <file>
        <name>$PROJ_DIR$\Sources\Drivers\PWM\PWM.c</name>
      </file>
    </group>
    <group>
      <name>SCI</name>
      <file>
        <name>$PROJ_DIR$\Sources\Drivers\SCI\SCI.c</name>
      </file>
    </group>
    <group>
      <name>Timer</name>
      <group>
        <name>IC</name>
        <file>
          <name>$PROJ_DIR$\Sources\Drivers\Timer\IC\IC.c</name>
        </file>
      </group>
      <group>
        <name>PIT</name>
        <file>
          <name>$PROJ_DIR$\Sources\Drivers\Timer\PIT\PIT.c</name>
        </file>
      </group>
    </group>
  </group>
  <group>
    <name>Headers</name>
    <group>
      <name>Delay</name>
      <file>
        <name>$PROJ_DIR$\Sources\Headers\Delay\Delay.h</name>
      </file>
    </group>
    <group>
      <name>IO</name>
      <file>
        <name>$PROJ_DIR$\Sources\Headers\IO\IO.h</name>
      </file>
    </group>
    <group>
      <name>PLL</name>
      <file>
        <name>$PROJ_DIR$\Sources\Headers\PLL\PLL.h</name>
      </file>
    </group>
    <group>
      <name>PWM</name>
      <file>
        <name>$PROJ_DIR$\Sources\Headers\PWM\PWM.h</name>
      </file>
    </group>
    <group>
      <name>SCI</name>
      <file>
        <name>$PROJ_DIR$\Sources\Headers\SCI\SCI.h</name>
      </file>
    </group>
    <group>
      <name>Timer</name>
      <group>
        <name>IC</name>
        <file>
          <name>$PROJ_DIR$\Sources\Headers\Timer\IC\IC.h</name>
        </file>
      </group>
      <group>
        <name>PIT</name>
        <file>
          <name>$PROJ_DIR$\Sources\Headers\Timer\PIT\PIT.h</name>
        </file>
      </group>
    </group>
    <file>
      <name>$PROJ_DIR$\Sources\Headers\COMMON.h</name>
    </file>
  </group>
  <group>
    <name>Image</name>
    <file>
      <name>$PROJ_DIR$\Sources\Image\Image.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Sources\Image\Image.h</name>
    </file>
  </group>
  <group>
    <name>INF_PROCESS</name>
    <file>
      <name>$PROJ_DIR$\Sources\INF_PROCESS\INF_PROCESS.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Sources\INF_PROCESS\INF_PROCESS.h</name>
    </file>
  </group>
  <group>
    <name>MCU</name>
  </group>
  <group>
    <name>OV7725</name>
    <file>
      <name>$PROJ_DIR$\Sources\OV7725\bsp_fifo.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Sources\OV7725\bsp_fifo.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Sources\OV7725\bsp_sccb.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Sources\OV7725\bsp_sccb.h</name>
    </file>
  </group>
  <group>
    <name>Sources</name>
    <file>
      <name>$PROJ_DIR$\Sources\Sources\main.c</name>
    </file>
  </group>
  <group>
    <name>User</name>
    <file>
      <name>$PROJ_DIR$\Sources\User\Users.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Sources\User\Users.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Sources\User\&#x8D44;&#x6e90;&#x5206;&#x914D;.txt</name>
    </file>
  </group>
  <file>
    <name>$PROJ_DIR$\Sources\derivative.h</name>
  </file>
</project>


