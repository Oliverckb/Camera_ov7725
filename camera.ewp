# IAR project camera.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: D:\singlechip computer\K60单片机\摄像头工程\Sources\Headers; D:\singlechip computer\K60单片机\摄像头工程\Sources\User; D:\singlechip computer\K60单片机\摄像头工程\Sources\Headers\IO; D:\singlechip computer\K60单片机\摄像头工程\Sources\Drivers\IO; D:\singlechip computer\K60单片机\摄像头工程\Sources\Headers\PLL; D:\singlechip computer\K60单片机\摄像头工程\Sources\Headers\PWM; D:\singlechip computer\K60单片机\摄像头工程\Sources\Headers\SCI; D:\singlechip computer\K60单片机\摄像头工程\Sources\Headers\Delay; D:\singlechip computer\K60单片机\摄像头工程\Sources\Headers\Timer\IC; D:\singlechip computer\K60单片机\摄像头工程\Sources\Headers\Timer\PIT; D:\singlechip computer\K60单片机\摄像头工程\Sources\Image; D:\singlechip computer\K60单片机\摄像头工程\Sources\INF_PROCESS; D:\singlechip computer\K60单片机\摄像头工程\Sources; D:\singlechip computer\K60单片机\摄像头工程\Sources; D:\singlechip computer\K60单片机\摄像头工程\Sources\User; D:\singlechip computer\K60单片机\摄像头工程\Sources\Control\Identify; D:\singlechip computer\K60单片机\摄像头工程\Sources\Control\Motor; D:\singlechip computer\K60单片机\摄像头工程\Sources\Control\Servo; D:\singlechip computer\K60单片机\摄像头工程\Sources\Control\Speed; D:\singlechip computer\K60单片机\摄像头工程\Sources\OV7725
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: camera.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    Sources/: derivative.h
  group Control/Identify
    Sources/Control/Identify/: Identify.c Identify.h
  group Control/Motor
    Sources/Control/Motor/: Motor.c Motor.h
  group Control/Servo
    Sources/Control/Servo/: Servo.c Servo.h
  group Control/Speed
    Sources/Control/Speed/: Speed.c Speed.h
  group Drivers/Delay
    Sources/Drivers/Delay/: Delay.c
  group Drivers/IO
    Sources/Drivers/IO/: IO.c
  group Drivers/PLL
    Sources/Drivers/PLL/: PLL.c
  group Drivers/PWM
    Sources/Drivers/PWM/: PWM.c
  group Drivers/SCI
    Sources/Drivers/SCI/: SCI.c
  group Drivers/Timer/IC
    Sources/Drivers/Timer/IC/: IC.c
  group Drivers/Timer/PIT
    Sources/Drivers/Timer/PIT/: PIT.c
  group Headers
    Sources/Headers/: COMMON.h
  group Headers/Delay
    Sources/Headers/Delay/: Delay.h
  group Headers/IO
    Sources/Headers/IO/: IO.h
  group Headers/PLL
    Sources/Headers/PLL/: PLL.h
  group Headers/PWM
    Sources/Headers/PWM/: PWM.h
  group Headers/SCI
    Sources/Headers/SCI/: SCI.h
  group Headers/Timer/IC
    Sources/Headers/Timer/IC/: IC.h
  group Headers/Timer/PIT
    Sources/Headers/Timer/PIT/: PIT.h
  group Image
    Sources/Image/: Image.c Image.h
  group INF_PROCESS
    Sources/INF_PROCESS/: INF_PROCESS.c INF_PROCESS.h
  group OV7725
    Sources/OV7725/: bsp_fifo.c bsp_fifo.h bsp_sccb.c bsp_sccb.h
  group Sources
    Sources/Sources/: main.c
  group User
    Sources/User/: Users.c Users.h 资源分配.txt
